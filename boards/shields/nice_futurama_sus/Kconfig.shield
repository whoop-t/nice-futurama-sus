## boards/shields/nice_futurama_sus/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_FUTURAMA_SUS
    def_bool $(shields_list_contains,nice_futurama_sus)
```
